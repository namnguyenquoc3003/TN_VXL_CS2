# Keil uVision project ds18b20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: ds18b20 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c STARTUP.A51
    ./LCD1602/: lcd1602.c
    ./DELAY/: delay.c
    ./DS1820/: ds18b20.c
